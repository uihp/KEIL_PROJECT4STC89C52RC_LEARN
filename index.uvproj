# Keil uVision project index.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: index +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h T0.c T0.h LCD1602.c LCD1602.h
